# SPDX-License-Identifier: MIT
require mesa-opentina-version.inc
